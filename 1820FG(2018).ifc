Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-12T13:49:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 13:49:44 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{E4806DB2-277B-4685-A73F-D9E390FCAE04}\ifc * Database version: 5507 * Database creation date: Wed Jun 12 13:49:43 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 13:49:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 13:49:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1820FG Kitchen faucet, 1820FG(2018):1820FG Kitchen faucet:321217
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 253.8 mm; NominalHeight: 183.6 mm; NominalWidth: 54 mm; Projection: 214 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1820FG(2018); ConvergoRefNr: 0087-1906-0037-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 11/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150089541; EN Standard: EN 817; LVI Number: 6219154; Noise Class: I (ISO 3822); RSK Number: 8310964
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1820FG; Catalog Drawing URL: http://static.oras.com/catdrw/1820FG; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1820FG; FDV Document URL: http://www.oras.com/datasheet/1820FG/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1820FG; Group: Kitchen faucets; Long Marketing: Kitchen faucet. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 40°-80°). Lever is equipped with an eco-button for limiting flow-rate, which can be bypassed by pressing the button. With flexible pipes. Electrical connection 9 V or 12 V via a separate power supply (e.g. Oras No. 199275).; Manufacturer: Oras; Market: INT;FIN;SWE;POL;EST;LTU;LVA;UKR; Model: 1820FG Kitchen faucet; Name_en: 1820FG Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 362 x 278 x 63; Package Weight: 2 kg; Product Code: 1820FG; Product Datasheet: http://www.oras.com/datasheet/1820FG/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1820FG; Product URL: http://static.oras.com/1820FG; Type Name: 1820FG Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: Flexible inlet pipes; Connection Size: G3/8; Eco Flow At 300kPa: 0.00600349 m3/s; Flow Rate At 300kPa: 0.00988811 m3/s; Installation and Maintenance: http://static.oras.com/manual/1820FG; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pressure Loss With Flow 02ls: 150000 Pa; Recognition Range: optimally preset; Spare Parts: http://static.oras.com/sp/1820FG; Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1820FG(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1820FG; Name: 1820FG Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 55x255x185 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1820FG; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1820FG Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0712995 m2; Volume: 0.0025204 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1820FG(2018): 1820FG Kitchen faucet; Family and Type: 1820FG(2018): 1820FG Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1820FG(2018): 1820FG Kitchen faucet; Type Id: 1820FG(2018): 1820FG Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
